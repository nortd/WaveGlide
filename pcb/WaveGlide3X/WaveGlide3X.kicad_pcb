# Repository nortd/WaveGlide

File README.md:

WaveGlide Oxygen System
========================

WaveGlide is an automatic oxygen delivery system for glider pilots. It prevents hypoxia at high altitudes by adding oxygen to the inhaled air. Unlike medical constant flow systems it pulses the oxygen supply at the beginning of the breathing cycle and automatically adapts oxygen levels to altitude.

For details see the [Project Website](http://nortd.github.io/WaveGlide/).

## KiCad design pcb/WaveGlide3X/WaveGlide3X.kicad_pcb

Parts:
AIRTEC1: AIRTEC; Airtec_M20_B_1MH
BATCONN1: BATCONN
BMP280: BMP280; Adafruit_BMP280
BOOSTCONV1: BOOSTCONV; PTN04050CAD
C1, C2: 100uF; CP_Radial_D8.0mm_P3.50mm
CHARGER1: CHARGER; Adafruit_Charger_4410
D1: D; D_A-405_P10.16mm_Horizontal
DIFFPRESSURE1: PressSensor; DIFFPRESS
Feather_M0_BLE1: Feather_M0_BLE
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3_Pad_Via
PIEZOCONN1: PIEZOCONN; PIEZO
PIEZOCONN17: PIEZOCONN; PIEZO_17
POWERSWITCH1: POWERSWITCH; TE_Switch
PROBEJACK1: PROBEJACK; DB9HARTING
Q1: KSC1815; TO-92L_Inline_Wide
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 30; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R8: 360; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 1.33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
STATUSRGB1: STATUSRGB; RGBA_5mm
VALVESSR1, VALVESSR2: VALVESSR; SSR
YS2000PROBE1: YS2000PROBE; YS2000

Connections:
+3V3: BMP280.1, DIFFPRESSURE1.2, Feather_M0_BLE1.2, PIEZOCONN17.1, R9.2, STATUSRGB1.2 (A), YS2000PROBE1.4
GND: AIRTEC1.2, BATCONN1.2, BMP280.3, BOOSTCONV1.1, C1.2, C2.2, CHARGER1.4, D1.2 (A), DIFFPRESSURE1.4, Feather_M0_BLE1.4, PROBEJACK1.1, PROBEJACK1.6, PROBEJACK1.7, Q1.1 (E), R6.1, R7.2, VALVESSR1.2, VALVESSR2.2, YS2000PROBE1.3, YS2000PROBE1.7
IN_DIFFPRES: DIFFPRESSURE1.3, Feather_M0_BLE1.9
IN_USER1: Feather_M0_BLE1.6, PROBEJACK1.4
IN_USER2: Feather_M0_BLE1.7, PROBEJACK1.8
MISO: BMP280.5, Feather_M0_BLE1.13
MOSI: BMP280.6, Feather_M0_BLE1.12
unnamed: AIRTEC1.1, BOOSTCONV1.4, C2.1, D1.1 (K)
unnamed: BOOSTCONV1.3, VALVESSR2.3
unnamed: PIEZOCONN17.2, Q1.2 (C), R9.1
unnamed: Q1.3 (B), R10.2
unnamed: R1.2, STATUSRGB1.1 (RK)
unnamed: R2.2, STATUSRGB1.3 (BK)
unnamed: R3.2, STATUSRGB1.4 (GB)
unnamed: R4.1, VALVESSR1.1
unnamed: R7.1, VALVESSR2.4
unnamed: R8.1, VALVESSR2.1
OUT_BLUE: Feather_M0_BLE1.23, R2.1
OUT_BMP280_CS: BMP280.7, Feather_M0_BLE1.10
OUT_GREEN: Feather_M0_BLE1.22, R3.1
OUT_PIEZO1: Feather_M0_BLE1.19, PIEZOCONN1.1, R10.1
OUT_PIEZO2: Feather_M0_BLE1.20, PIEZOCONN1.2
OUT_RED: Feather_M0_BLE1.24, R1.1
OUT_VALVE: Feather_M0_BLE1.25, R4.2
OUT_VCONV: Feather_M0_BLE1.8, R8.2
PHOTO_AN: PROBEJACK1.5, YS2000PROBE1.8
PHOTO_CA: PROBEJACK1.9, YS2000PROBE1.9
RED_AN: PROBEJACK1.3, YS2000PROBE1.5
RED_CA: PROBEJACK1.2, YS2000PROBE1.6
RX: Feather_M0_BLE1.14, YS2000PROBE1.1
SCK: BMP280.4, Feather_M0_BLE1.11
TX: Feather_M0_BLE1.15, YS2000PROBE1.2
VBAT: BATCONN1.1, POWERSWITCH1.2, POWERSWITCH1.5, VALVESSR1.4
VBAT_OFF: CHARGER1.5, POWERSWITCH1.3, POWERSWITCH1.6
VBAT_ON: Feather_M0_BLE1.28, POWERSWITCH1.1, POWERSWITCH1.4
VBAT_SSR: BOOSTCONV1.2, C1.1, VALVESSR1.3
VUSB: CHARGER1.1, Feather_M0_BLE1.26, R5.2
VUSB_SENSE: Feather_M0_BLE1.5, R5.1, R6.2

Notes on the sheet:
Li-Ion 1S1P 3.7V 2600mA
POWERSWITCH in connects VBAT to VBAT_ON POWERSWITCH out connects VBAT to VBAT_OFF
USB-disconnected & ON: bat-pwd, no charging USB-disconnected & OFF: off, no charging USB-connected & ON: usb-pwd, slow-charging (feather) USB-connected & OFF: usb-pwd, fast-charging (charging screen)

Board: 2 copper layers, 89.0 x 95.0 mm, 32 parts (0 on the bottom side), 38 nets.

## KiCad design pcb/WaveGlideNG/WaveGlideNG.kicad_pcb

Board: 2 copper layers, 72.0 x 70.0 mm, 20 parts (2 on the bottom side), 28 nets.

Parts:
BATCONN1: BAT+; VALECONN
BATCONN2: BAT-; VALECONN
BMP280: BMP280; Pin_Header_Straight_1x07_Pitch2.54mm
D1: D; D_A-405_P10.16mm_Horizontal
DIFFPRESSURE1: PressSensor; DIFFPRESS
FEATHERBLELONG1: FEATHERBLELONG; PinHeader_1x16_P2.54mm_Vertical
FEATHERBLESHORT1: FEATHERBLESHORT; PinHeader_1x12_P2.54mm_Vertical
PIEZOCONN1: PIEZOCONN; PIEZO
POWERSWITCH1: PWRSWITCH; TE_Switch
PROBEJACK1: PROBEJACK; DB9HARTING
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 30; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 360; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
STATUSRGB1: STATUSRGB; RGBA_5mm
VALVECONN1, VALVECONN2: VALVECONN; VALECONN
VALVESSR1: VALVESSR; SSR
YS2000PROBE1: YS2000PROBE; Pin_Header_Straight_1x05_Pitch2.54mm
YS2000UART1: YS2000UART; Pin_Header_Straight_1x04_Pitch2.54mm

Connections:
+3V3: BMP280.1, DIFFPRESSURE1.2, FEATHERBLELONG1.15, STATUSRGB1.2, YS2000UART1.4
/MISO: BMP280.5, FEATHERBLELONG1.4
/MOSI: BMP280.6, FEATHERBLELONG1.5
/RX: FEATHERBLELONG1.3, YS2000UART1.2
/SCK: BMP280.4, FEATHERBLELONG1.6
/TX: FEATHERBLELONG1.2, YS2000UART1.1
/VBAT: BATCONN1.1, FEATHERBLESHORT1.12, VALVESSR1.4
GND: BATCONN2.1, BMP280.3, D1.2, DIFFPRESSURE1.4, FEATHERBLELONG1.13, POWERSWITCH1.2, PROBEJACK1.1, PROBEJACK1.6, PROBEJACK1.7, VALVECONN2.1, VALVESSR1.2, YS2000PROBE1.3, YS2000UART1.3
IN_DIFFPRES: DIFFPRESSURE1.3, FEATHERBLELONG1.8
IN_USER1: FEATHERBLELONG1.11, PROBEJACK1.4
IN_USER2: FEATHERBLELONG1.10, PROBEJACK1.8
unnamed: D1.1, VALVECONN1.1, VALVESSR1.3
unnamed: R1.2, STATUSRGB1.1
unnamed: R2.2, STATUSRGB1.3
unnamed: R3.2, STATUSRGB1.4
unnamed: R4.1, VALVESSR1.1
OUT_BLUE: FEATHERBLESHORT1.7, R2.1
OUT_BMP280_CS: BMP280.7, FEATHERBLELONG1.7
OUT_GREEN: FEATHERBLESHORT1.6, R3.1
OUT_PIEZO1: FEATHERBLESHORT1.3, PIEZOCONN1.1
OUT_PIEZO2: FEATHERBLESHORT1.4, PIEZOCONN1.2
OUT_RED: FEATHERBLESHORT1.8, R1.1
OUT_VALVE: FEATHERBLESHORT1.9, R4.2
PHOTO_AN: PROBEJACK1.5, YS2000PROBE1.4
PHOTO_CA: PROBEJACK1.9, YS2000PROBE1.5
POWERDISABLE: FEATHERBLESHORT1.11, POWERSWITCH1.1
RED_AN: PROBEJACK1.3, YS2000PROBE1.1
RED_CA: PROBEJACK1.2, YS2000PROBE1.2

## Commit log

2015-08-24 planning
2015-10-06 fritzing and freecad files added
2015-10-12 src added
2015-10-12 testing out some modules
2015-10-14 rhythm files added, before moving large block
2015-10-14 some following
2015-10-14 breathing response quite usable, indeed
2015-10-15 super decent without evalve nor oxygen
2015-10-15 super decent with top spike rejection
2015-10-16 working it
2015-10-18 working pcb
2015-10-18 all pcb todos
2015-10-18 at autorouting, cutout still missing
2015-10-19 cutout added
2015-10-19 cutout adj
2015-10-19 routed, checked, ground fill
2015-10-20 altitude compensation
2015-10-22 working on ui
2015-10-29 minor
2015-11-01 sense battery
2015-11-01 battery and adj added
2015-11-02 banging my head at buttons
2015-11-02 button working
2015-11-02 button working better
2015-11-18 pcb updated, pre rotate sensor
2015-11-20 code tunings
2015-11-20 breathing response superb
2015-11-20 working firmware!
2015-11-20 firmware code cleaned
2015-11-21 casing, lower shell
2015-11-26 Update README.md
    minor
2015-11-26 images added
2015-11-26 Update README.md
    immages added
2016-01-23 code cleanified
2016-01-24 rhythm parameters adjusted
2016-01-27 readme updated
2016-01-27 dir structure clean up
2016-01-27 dir structure
2016-02-08 case polishiinggg
2016-02-10 round awesome buttons
2016-02-10 case two done
2016-02-10 case two done, stls added
2016-03-07 model
2016-03-08 title animation
2016-03-08 baseline filter adjusted
2016-03-08 new altitude adaptation function
2016-03-08 flat breath opti
2016-03-09 before reducing adjustment options to 4
2016-03-09 alt curve adjust, pct adjustments to 4 (instead of 5), color adjustments
2016-03-09 tunings
2016-03-10 curve/setting tunings
2016-03-29 altitude adjustments, battery color
2016-05-10 altitude curve slightly lowered. Default setting equals roughly the former low setting.
2016-05-29 some untracked files added
2016-06-02 double and quadro mode, default start alt reduced to FL80
2016-06-02 rhythm smoothing added, feels more calming
2017-10-19 docs added (gh-pages)
2017-10-19 bootloader
2017-10-19 nortd link
2019-09-13 PCB started
2019-09-13 footprints
2019-09-16 v0.1 PCB ordered
2019-09-18 fixed edge cut for holes as complained by eurocircuits
2019-10-31 firmware_ng for feather M0 added, roughly working
2019-11-02 3X started
2019-11-03 first pcb layout
2019-11-03 second pcb layout
2019-11-03 before routing
2019-11-03 first routing
2019-11-04 roughly routed
2019-11-04 configurable valve voltage added
2019-11-04 as exported
2019-11-04 routing radii adjusted
2019-11-04 as finished for 3X v3.1
2019-11-12 board 3X v3.1 as ordered
2019-11-12 BMP120 init changes so it does not get blocked by BLE on the same SPI
2019-11-24 protocol update code cleanup and compile check
2019-11-25 testing and fixing
2020-03-05 correction to schematic, pre-routing
2020-03-05 changed feather footprint 180, routing
2020-03-08 routing
2020-03-09 routing final touches
2020-03-10 v3.2 as quoted
2020-03-23 buzzer pin for v3.2
2020-04-05 protocol Waveglide 3X reworked
2020-04-05 renamed from ng to 3X
2020-04-18 rgb off fixed
2020-04-18 firmware cleanup, ramping up to add new led/buzzer status and SPO2 auto adjustment
2020-04-18 make it compile
2020-04-18 rudimentary bat status
2020-04-19 user feedback tuned, diff pressure sensitivity tuned
2020-04-19 simple pulsoxy mode implemented
2020-04-19 fixed data type bug related to time schduling variables
2020-04-20 switched to MIT license
2020-04-20 AutoPID for SPO2 added, not tested
2020-04-20 pid pulsoxy mode when probe is measuring, 100% mode when probe present and not measuring, baro mode when probe disconnected
2020-04-22 setpoiny yo 96, max to 88
2020-05-12 charging feedback added
2020-05-12 charging feedback tuned
2020-07-03 charging loop disabled, empiric check value not reliable
2020-10-01 PID parameters adjusted
2020-10-01 Flutter app added
2020-10-01 Configs and gitignore fixed
2020-10-19 regulation of oxygen_pct changed, primarily in baro mode, if pulsoxy data available the baro curve gets to be modulated up and down accordingly, algo description in handle_pulsoxy_adjust(). Aslo a ne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

Notices in the files:
pcb/WaveGlide3X/WaveGlide3X.kicad_pcb:
(c) 2020 Nortd Labs
pcb/WaveGlideNG/WaveGlideNG.kicad_pcb:
(c) 2019 Nortd Labs
